# IAR project Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: SDi_2000_FrontPanel.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group Lib/inc
    ../../STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_beep.h stm8s_clk.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_tim3.h
  group Lib/src
    ../../STM8S_StdPeriph_Driver/src/: stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_tim3.c
  group Project/inc
    ../inc/: app.h app_beep.h app_clk.h app_gpio.h app_i2c.h app_iwdg.h app_menu.h app_tim.h stm8s_conf.h stm8s_it.h
  group Project/src
    ../src/: app.c app_beep.c app_clk.c app_gpio.c app_i2c.c app_iwdg.c app_menu.c app_tim.c character_matrix.c CppTest.cpp main.c stm8s_it.c
