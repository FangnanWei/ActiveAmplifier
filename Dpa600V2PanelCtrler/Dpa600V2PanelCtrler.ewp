# IAR project Dpa600V2PanelCtrler.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x300
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: include; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Dpa600V2PanelCtrler.hex
  ILINK.IlinkOutputFile: Dpa600V2PanelCtrler.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s105k6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group include
    include/: 24C02.h Delay.h Encoder.h Fifo.h GlobalVal.h gpio.h I2c.h Key.h Lcd.h led.h LedLightBar.h Menu.h Packet.h SpiLcd.h stm8s_conf.h stm8s_it.h timer.h Uart.h
  group Src
    Src/: 24C02.c AlgCfg.c Delay.c Encoder.c Fifo.c FontsAndLogos.c gpio.c I2c.c key.c lcd.c led.c LedLightBar.c main.c Menu.c Packet.c SpiLcd.c Ssd1306.c stm8s_it.c timer.c Uart.c
  group STM8S_StdPeriph_Driver/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group STM8S_StdPeriph_Driver/Src
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_uart2.c
