# Keil uVision project Motherboard.uvprojx, settings and files
target Motherboard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Motherboard +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,AP
  c misc: --cpp11
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\ADAU1701;..\User\AP;..\User\Common;..\User\McuIf
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries/CMSIS/CM3/CoreSupport
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Libraries/STM32F10x_StdPeriph_Driver/src
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User/ADAU1701
    ../User/ADAU1701/: ADAU1701-gpio-test_IC_1.cpp
  group User/AP
    ../User/AP/: Adc.cpp dsp.cpp eeprom.cpp Gpio.cpp I2C.cpp key.cpp main.cpp reset.cpp Scene.cpp Time.cpp tpa5050.cpp stm32f10x_it.cpp
  group User/Common
    ../User/Common/: flash_if.cpp iap.cpp led.cpp packet.cpp uart.cpp
  group User/McuIf
    ../User/McuIf/: comfifo.cpp McuMsg.cpp
