# IAR project FrontPanel.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207K8 STM8S207K8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x800
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\STM8S_StdPeriph_Driver\inc; ..\inc
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: FrontPanel.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group inc/App
    ../inc/App/: comfifo.h Menu.h
  group inc/Driver/Chip
    ../inc/Driver/Chip/: Eeprom.h Key.h Oled.h RotaryEncoder.h
  group inc/Driver/St
    ../inc/Driver/St/: Gpio.h I2c.h stm8s_it.h Sys.h Uart.h
  group inc/Nip
    ../inc/Nip/: Argument.h
  group inc/Util
    ../inc/Util/: Array.h StringUtil.h
  group src
    ../src/: main.cpp
  group src/App
    ../src/App/: comfifo.c Menu.cpp
  group src/Driver/Chip
    ../src/Driver/Chip/: Eeprom.cpp Key.cpp Oled.cpp RotaryEncoder.cpp
  group src/Driver/St
    ../src/Driver/St/: Gpio.cpp I2c.cpp stm8s_it.c Sys.cpp Uart.cpp
  group src/Nip
    ../src/Nip/: Argument.cpp
  group src/Util
    ../src/Util/: StringUtil.cpp
  group STM8S_StdPeriph_Driver/inc
    ../STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_conf.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group STM8S_StdPeriph_Driver/src
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
