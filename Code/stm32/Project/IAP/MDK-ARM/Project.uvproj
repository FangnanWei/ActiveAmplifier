# Keil uVision project Project.uvproj, settings and files
target MaxPLC_Server (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MaxPLC_Server +hex
  AfterMake: fromelf.exe --bincombined --output "$L@L.bin" "$L@L.axf
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,MaxPLC_Server
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities;..\..\..\wpa_supplicant\src;..\..\..\wpa_supplicant\src\common;..\..\..\wpa_supplicant\src\eap_common;..\..\..\wpa_supplicant\src\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Common
    ../../../Common/: flash_if.c led.c packet.c uart.c iap.c
  group mcuIf
    ../../../mcuIf/: comfifo.c McuMsg.c
target IAP (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IAP +hex
  AfterMake: fromelf.exe --bincombined --output "$L@L.bin" "$L@L.axf
  c flags: OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,__IAP__
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\include;..\..\..\Utilities;..\..\..\mcuIf;..\..\..\Common;..\User;..\..\AP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
